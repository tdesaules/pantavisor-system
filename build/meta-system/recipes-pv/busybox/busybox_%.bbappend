FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://ventuno-network.cfg"
